## drivers/agv-fpga/Kconfig
```kconfig
#
# FPGA framework configuration
#

menu "AGV FPGA Support"

config AGV_FPGA
	tristate "AGV FPGA Support"
	help
	  AGV FPGA Support

endmenu
```
